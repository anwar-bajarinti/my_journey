# Keil uVision project MICROCONTROLLER PROGRAMS.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89C51RD2xx NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: MICROCONTROLLER PROGRAMS
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: TRAFFIC_MECHANISM.asm
