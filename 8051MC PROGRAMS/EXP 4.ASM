ORG 00H
	MOV P2,#0FFH
	MOV TMOD,#20H
	MOV TH1,#3
	MOV SCON,#50H
	SETB TR1;
	MOV DPTR,#MYDATA;
	H1:CLR AAAAAA
	MOVC A,@A+DPTR;
	JZ RECV;
	ACALL SEND;
	INC DPTR;
	SJMP H1;
	SEND:MOV SBUF,A;
	H2:JNB TI,H2;
	CLR TI;
	RET;
	RECV:
	H3:JNB RI,H3;
	CLR RI;
	MOV A,SBUF;
	MOV P2,A;
	SJMP RECV;
	MYDATA:DB "WELCOME TO MICROCONTROLLER PROGRAMMING",0;
		END