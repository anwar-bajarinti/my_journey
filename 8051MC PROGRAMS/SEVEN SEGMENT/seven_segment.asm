ORG 0400H
	DB 3FH,06H,5BH,4FH,66H,60H,7DH,07H,7FH,6FH,0
		ORG 0000H
			MOV DPTR,#0400H
			AGAIN:MOV A,#03H
			MOVC A,@A+DPTR
			MOV P2,#08H
			MOV P1,A
			ACALL DELAY
			MOV A,#00H
			MOVC A,@A+DPTR
			MOV P2,#04H
			MOV P1,A
			ACALL DELAY
			MOV A,#01H
			MOVC A,@A+DPTR
			MOV P2,#02H
			MOV P1,A
			ACALL DELAY
			MOV A,#08H
			MOVC A,@A+DPTR
			MOV P2,#01H
			MOV P1,A
			ACALL DELAY
			SJMP AGAIN
				DELAY:MOV R0,#90H
				WAIT1:MOV R1,#0FFH
				WAIT2:MOV R2,#0FFH
				WAIT3:DJNZ R2,WAIT3
				DJNZ R1,WAIT2
				DJNZ R0,WAIT1
				RET
				END