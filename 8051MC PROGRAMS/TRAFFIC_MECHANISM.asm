ORG 00H
	MOV TMOD,#01H
	MOV DPTR ,#0FFC0H
	L1:MOV A,#6AH
	MOVX @DPTR,A;
	MOV P1,A;
	ACALL DELAY;
	MOV A,#9AH
	MOVX @DPTR,A;
	MOV P1,A;
	ACALL DELAY;
	MOV A,#0A6H;
	MOVX @DPTR,A
	MOV P1,A;
	ACALL DELAY;
	MOV A,#0A9H
	MOVX @DPTR,A;
	MOV P1,A;
	ACALL DELAY;
	SJMP L1;
	DELAY:MOV R0,#0EH
	L2:MOV TL0,#00H
	MOV TH0,#00H;
	SETB TR0;
	HERE: JNB TF0,HERE;
	CLR F0;
	CLR TR0;
	DJNZ R0,L2;
	RET;
	END